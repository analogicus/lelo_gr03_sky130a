v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {OTA Bandgap Martin} -70 -90 0 0 0.4 0.4 {}
C {/home/marti/pro/aicex/ip/lelo_gr03_sky130a/design/LELO_ATR_SKY130A/LELOATR_PCH_4C5F0.sym} -110 10 0 1 {name=x1 }
