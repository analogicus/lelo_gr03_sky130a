v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {JNW_ATR_SKY130A/JNWATR_NCH_4C5F0.sym} -40 50 0 0 {name=x1 }
